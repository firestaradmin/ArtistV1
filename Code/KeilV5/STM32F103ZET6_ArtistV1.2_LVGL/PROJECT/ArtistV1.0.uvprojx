# Keil uVision project ArtistV1.0.uvprojx, settings and files
target NestlingV2.0_CPP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ArtistV1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,STM32
  c include: ..\Lib\FWLib\inc;..\Lib\CORE;..\USER;..\Bsp\TIM;..\Bsp\USART;..\Bsp\delay;..\Bsp\LCD_ILI9486;..\GRBL_0.9j;..\GRBL_0.9j\defaults;..\GRBL_0.9j\cpu_map;..\Bsp\EXTI;..\Bsp\PWM;..\Bsp\SDIO;..\FATS\src;..\FATS\exfuns;..\LVGL;..\LVGL\src;..\Bsp\UVGUI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: stm32f10x_it.c stm32f10x_conf.h main.c
  group BSP
    ../Bsp/LED/: LED.c
    ../Bsp/TIM/: myTIM.c
    ../Bsp/delay/: delay.c
    ../Bsp/W25QXX/: w25qxx.c
    ../Bsp/SPI/: spi.c
    ../Bsp/USART/: usart.c
    ../Bsp/LCD_ILI9486/: LCD_ILI9486.c
    ../Bsp/24CXX/: 24cxx.c
    ../Bsp/IIC/: myiic.c
    ../Bsp/EXTI/: HW_EXTI.c
    ../Bsp/PWM/: HW_PWM.c
    ../Bsp/SDIO/: sdio_sdcard.c
  group FWLib
    ../Lib/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../Lib/CORE/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group UVGUI
    ../Bsp/UVGUI/: UVGUI.c UVGUI.h UVGUI_UserConfig.h UVGUI_Animation.c UVGUI_Animation.h UVGUI_Touch.c UVGUI_Touch.h
  group GRBL0.9
    ../GRBL_0.9j/: coolant_control.c eeprom.c gcode.c limits.c motion_control.c nuts_bolts.c planner.c print.c probe.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c system.c
  group FATS
    ../FATS/src/: diskio.c ff.c
    ../FATS/src/option/: cc936.c
    ../FATS/exfuns/: exfuns.c fattester.c
  group LVGL/Config
    ../LVGL/: lv_conf.h lv_port_disp.c lv_port_disp.h lvgl.h lv_myApp.c lxg_logo.c
  group LVGL
    ../LVGL/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../LVGL/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c
    ../LVGL/src/lv_gpu/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../LVGL/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
